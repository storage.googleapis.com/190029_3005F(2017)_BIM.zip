Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-20T11:04:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 20 11:04:13 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{0ACC7347-7D91-480B-A08B-363F2FC243F2}\ifc * Database version: 5507 * Database creation date: Wed Jun 20 11:04:12 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 20 11:04:13 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 20 11:04:13 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: 3005F Washbasin faucet, 3 V, 3005F(2017):3005F Washbasin faucet, 3 V:349144
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - FaucetNominalDepth: 191 mm; FaucetNominalHeight: 238.5 mm; FaucetNominalWidth: 104 mm; HandShowerNominalDepth: 68.5 mm; HandShowerNominalHeight: 367.5 mm; HandShowerNominalWidth: 57 mm; InletConnectionSize: 10 mm; Projection: 150 mm
Type - Electrical - Battery: AA 1.5 V Lithium x 2, CR 2450 3 V; Operating Voltage: 3 V
Type - General - Author: Convergo AB; BIMObjectName: 3005F; ConvergoRefNr: 0087-1806-0099-FI; ExpiringDate: 12/2018; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for washbasins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/06/2018
Type - Green Building Properties - EAN Number: 6414150082412; EMC Directive: 2014/30/EU; EN Standard: EN 15091; Noise Class: I (ISO 3822); Protection Class: IP 55; RSK Number: 8277832; VVS Number: 703912204
Type - Identity Data - Class: Side operated, single lever, battery operated; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 3005F Washbasin faucet, 3 V; Name_en: 3005F Washbasin faucet, 3 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 3005F; Product Family: Oras Inspera; Type Name: 3005F Washbasin faucet, 3 V
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Installation Type: Deck mounted; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Pressure Loss With Flow 01ls: 100000 Pa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3005F(2017); Features: Side operated, single lever, battery operated; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3005F; Name: 3005F Washbasin faucet, 3 V; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:104x191x239 mm / Hand shower: 57x69x368 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3005F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3005F Washbasin faucet, 3 V
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Host: Level : Level 0; Level: Level: Level 0; Offset: 0 mm
Dimensions - Area: 0.141313 m2; Volume: 0.0061747 m3
Identity Data - Mark: 24
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 3005F(2017): 3005F Washbasin faucet, 3 V; Family and Type: 3005F(2017): 3005F Washbasin faucet, 3 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3005F(2017): 3005F Washbasin faucet, 3 V; Type Id: 3005F(2017): 3005F Washbasin faucet, 3 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
